ORG 0000H
 SJMP START
 ORG 4000H
	 DB 3FH, 06H, 5BH, 4FH, 66H, 6DH, 7DH, 07H, 7FH, 6FH, 0

ORG 0035H
	MOV P2, #00H
    START:MOV DPTR,#4000H
    REPEAT:CLR A;
    MOVC A, @A+DPTR
	MOV P2,A
	ACALL DELAY
	INC DPTR // point to next data
	CJNE A,0,REPEAT ; until we reach end of database
	SJMP START

DELAY: MOV R0, #15 // delay for 1 second
	MOV TMOD, #01H 
LOOP:MOV TH0, #00H
	MOV TL0, #00H
	SETB TR0
CHECK: JNB TF0, CHECK
	CLR TF0
	CLR TR0
	DJNZ R0, LOOP
RET

END